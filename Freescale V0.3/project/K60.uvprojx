# Keil uVision project K60.uvprojx, settings and files
target freescale (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: K60 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\System;..\System\SYS;..\System\STA;..\software;..\Hardware;..\Hardware\inc;..\Hardware\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group user
    ../System/: main.c
  group hardware
    ../Hardware/src/: freescale_gpio.c freescale_sim.c freescale_pit.c freescale_usart.c freescale_adc.c
  group system
    ../System/SYS/: System32.c system_MK60D10.c
  group core
    ../System/STA/: startup_MK60DZ10.s
  group H_file
    ../System/SYS/: Includes.h AllDefine.h common.h freescale_config.h
